# Keil uVision project SGCS.uvprojx, settings and files
target SGCS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: SGCS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F411xE,USE_STDPERIPH_DRIVER,HSE_VALUE=25000000
  c include: .cmsis\include;RTE\_Project;..\..\Drivers\CMSIS\Core;..\..\Drivers\CMSIS\Device;..\..\Drivers\STM32F4XX_Driver;..\..\Drivers\System;..\..\Middlewares\FreeRTOS\inc;..\..\Middlewares\FreeRTOS\port;..\..\Middlewares\FreeRTOS\src;..\..\Config;..\..\Tasks\Inc;..\..\Tasks\Src;..\..\Application\Inc;..\..\Application\Src;..\..\BSP\Inc;..\..\BSP\Src;..\..\Test;..\..;..\..\Config\Inc;..\..\Config\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../../: main.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
  group Config/Src
    ../../Config/Src/: SysClockConfig.c PeripheralParamConfig.c
  group Config/Inc
    ../../Config/Inc/: FreeRTOSConfig.h SysClockConfig.h PeripheralParamConfig.h
    ../../BSP/Inc/: bsp_pin_cfg.h
  group Middlewares/FreeRTOS/port
    ../../Middlewares/FreeRTOS/port/: heap_4.c port.c portmacro.h
  group Middlewares/FreeRTOS/src
    ../../Middlewares/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS/inc
    ../../Middlewares/FreeRTOS/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group Drivers/System
    ../../Drivers/System/: stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group Drivers/STM32F4XX_Driver
    ../../Drivers/STM32F4XX_Driver/: misc.c misc.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_can.c stm32f4xx_can.h stm32f4xx_cec.c stm32f4xx_cec.h stm32f4xx_crc.c stm32f4xx_crc.h stm32f4xx_cryp.c stm32f4xx_cryp.h stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dac.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dcmi.c stm32f4xx_dcmi.h stm32f4xx_dfsdm.c stm32f4xx_dfsdm.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_dma2d.c stm32f4xx_dma2d.h stm32f4xx_dsi.c stm32f4xx_dsi.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_flash_ramfunc.c stm32f4xx_flash_ramfunc.h stm32f4xx_fmpi2c.c stm32f4xx_fmpi2c.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_hash.c stm32f4xx_hash.h stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_lptim.c stm32f4xx_lptim.h stm32f4xx_ltdc.c stm32f4xx_ltdc.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_qspi.c stm32f4xx_qspi.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.c stm32f4xx_rng.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_sai.c stm32f4xx_sai.h stm32f4xx_sdio.c stm32f4xx_sdio.h stm32f4xx_spdifrx.c stm32f4xx_spdifrx.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h
  group Drivers/CMSIS/Device
    ../../Drivers/CMSIS/Device/: startup_stm32f411xe.s
  group Drivers/CMSIS/Core
    ../../Drivers/CMSIS/Core/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group BSP/Src
    ../../BSP/Src/: bsp_usart.c bsp_encoder.c bsp_debug.c bsp_oled.c bsp_ultrasonic.c
  group BSP/Inc
    ../../BSP/Inc/: bsp_usart.h bsp_encoder.h bsp_debug.h bsp_oled.h bsp_ultrasonic.h
